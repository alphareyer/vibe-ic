VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
 DATABASE MICRONS 1000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;
LAYER M1
 TYPE ROUTING ;
 DIRECTION HORIZONTAL ;
 PITCH 0.4 ;
 WIDTH 0.2 ;
 SPACING 0.2 ;
END M1
SITE core
 CLASS CORE ;
 SIZE 1 BY 1 ;
 SYMMETRY Y ;
END core
END LIBRARY
