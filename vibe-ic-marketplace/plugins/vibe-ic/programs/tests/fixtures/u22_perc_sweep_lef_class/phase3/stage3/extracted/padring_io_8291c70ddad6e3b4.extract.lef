VERSION 5.7 ;
MACRO gf180mcu_fd_io__bi_24t
  CLASS PAD INOUT ;
  ORIGIN 0.000 0.000 ;
  SIZE 75.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
END gf180mcu_fd_io__bi_24t
END LIBRARY
