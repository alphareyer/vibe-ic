VERSION 5.7 ;
MACRO gf180mcu_fd_io__fill5
  CLASS PAD SPACER ;
  ORIGIN 0.000 0.000 ;
  SIZE 5.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
END gf180mcu_fd_io__fill5
END LIBRARY
