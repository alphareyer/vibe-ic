VERSION 5.7 ;
MACRO gf180mcu_fd_io__brk2
  CLASS PAD ;
  ORIGIN 0.000 0.000 ;
  SIZE 2.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
END gf180mcu_fd_io__brk2
END LIBRARY
